# Keil uVision project STM32F103C8_FreeRTOS.uvprojx, settings and files
target STM32F103C8_FreeRTOS (6120000::V6.12::.\ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x08000000-0x0800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32F103C8_FreeRTOS +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=6 wLevel=2
  c define: STM32F103xB
  c misc: -Wno-missing-prototypes
  c include: .\Core\Inc;.\Drivers\CMSIS\Core\Include;.\Drivers\CMSIS\Device\ST\STM32F1xx\Include;.\Middlewares\Third_Party\FreeRTOS-Kernel\include;.\Middlewares\Third_Party\FreeRTOS-Kernel\portable\GCC\ARM_CM3
  asm define: STM32F103xB
  asm include: .\Drivers\CMSIS\Core\Include;.\Drivers\CMSIS\Device\ST\STM32F1xx\Include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application
    ./Core/Src/: main.c board.c
  group CMSIS
    ./Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xb.s
    ./Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group FreeRTOS Kernel
    ./Middlewares/Third_Party/FreeRTOS-Kernel/: tasks.c queue.c list.c timers.c event_groups.c stream_buffer.c croutine.c
    ./Middlewares/Third_Party/FreeRTOS-Kernel/portable/GCC/ARM_CM3/: port.c
    ./Middlewares/Third_Party/FreeRTOS-Kernel/portable/MemMang/: heap_4.c
